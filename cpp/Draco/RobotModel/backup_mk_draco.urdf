Commit message: debuging model

File: cpp/Draco/RobotModel/backup_mk_draco.urdf (robot description, URDF)
Before this commit: robot draco, 5 links, 4 joints
Links:
- link body: geometry visual mesh filename=meshes/body_edit.stl scale=0.001 0.001 0.001
